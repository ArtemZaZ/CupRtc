# Keil uVision project dummy.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: dummy +hex
  BeforeMake: .\src\retarget\update_commit_hash.bat
  AfterMake: .\src\retarget\remove_commit_hash.bat
  c flags: Optim=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F103xB, USE_FULL_ASSERT, STM32F10X_MD, USE_STDPERIPH_DRIVER, HSE_VALUE=8000000
  c misc: --feedback=unused  --cpp11
  c include: .\src\cmsis;.\src;.\src\mcu_support_package\inc;.\src\uart;.\src\spl\Libraries\STM32F10x_StdPeriph_Driver;.\src\spl\Libraries\STM32F10x_StdPeriph_Driver\inc;.\src\common_functions;.\src\circular_buffer;.\src\crc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --feedback=unused
  group common_functions
    ./src/common_functions/: common_functions.cpp common_functions.h
  group main
    ./src/main/: main.c cspeexparser.c
  group mcu_support_package
    ./src/mcu_support_package/arm/: startup_stm32f103xb.s
    ./src/mcu_support_package/: system_stm32f10x.c
  group retarget
    ./src/retarget/: retarget.cpp
  group uart
    ./src/uart/: uart_handle.cpp
  group spl
    ./src/spl/Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_gpio.c
software components: CMSIS:CORE 5.3.0
